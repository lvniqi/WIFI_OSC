## LINUX/test_gpio_interrupt/src/Kconfig
```kconfig
config GPIO_interrupt
	tristate "TEST GPIO INTERRUPT modules"
	depends on TARGET_ar71xx
	help
	  TEST GPIO INTERRUPT modules
```
